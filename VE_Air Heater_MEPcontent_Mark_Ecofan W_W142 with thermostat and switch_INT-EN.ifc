Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-10-08T15:03:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 08 15:03:24 2021 * Host: FCIOFLE-RO-LE * Database: C:\Users\FCiofle\AppData\Local\Temp\{F897F8D7-A95F-4DB6-A8EC-2219B5425366}\ifc * Database version: 5507 * Database creation date: Fri Oct 08 15:03:23 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Oct 08 15:03:23 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 08 15:03:23 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcAirTerminal: W142 with thermostat and switch, VE_Air Heater_MEPcontent_Mark_Ecofan W_INT-EN:W142 with thermostat and switch:1308792
In: V00
Type - Material: Color RGB 040-040-040, Color RGB 193-193-194, Color RGB 000-000-255, Color RGB 060-060-060
Type - Dimensions - Height: 452 mm; Length: 860 mm; Width: 860 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 535 W
Type - Identity Data - Article Type: W142 with thermostat and switch; Base Family Version: 12.32; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: ECOFAN with thermostat and switch; EMCS Version: 4.0; ETIM Article Class: EC011395; Family Version: 11.19; Manufacturer: Mark; Manufacturer URL: http://www.markclimate.com/ventilation-and-recirculation-equipment/ecofan-w/; MEPcontent Class: AIR_HEATER; Model: W142 with thermostat and switch; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Revit Version: 2019; Type Name: W142 with thermostat and switch; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Air Flow Rate: 0 m3/s; Heating Power: 0; Nominal Flow Rate: 0 m3/s
Type - Other - Category: Mechanical Equipment; Carcase Depth: 178.3 mm; Distance Between Horizontal Fan Grids: 15 mm; Distance Between Pendants: 797 mm; Distance Vertical Fan Grids: 210 mm; Family Name: VE_Air Heater_MEPcontent_Mark_Ecofan W_INT-EN; Fan Grid Length: 68 mm; Radius Fan Grid: 0 mm; W142: yes; W42: no; W82: no
Type - Text - Article Description: ECOFAN with thermostat and switch; GTIN: 87193336501200; Manufacturer Art. No.: 5065012; Product Line: Mark
Type - Pset_AirTerminalTypeCommon - Reference: W142 with thermostat and switch
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Area: 3.94378 m2; Pendant Length: 138 mm; Volume: 0.192958 m3
Identity Data - Mark: 4
Mechanical - System Classification: Power
Other - Family: VE_Air Heater_MEPcontent_Mark_Ecofan W_INT-EN: W142 with thermostat and switch; Family and Type: VE_Air Heater_MEPcontent_Mark_Ecofan W_INT-EN: W142 with thermostat and switch; Offset Switch: 222.8 mm; Pendant Length Safe: 138 mm; Type: VE_Air Heater_MEPcontent_Mark_Ecofan W_INT-EN: W142 with thermostat and switch; Type Id: VE_Air Heater_MEPcontent_Mark_Ecofan W_INT-EN: W142 with thermostat and switch
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Switch Visible: yes; Thermostat Visible: yes
